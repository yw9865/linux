## drivers/staging/cysec/Kconfig
```kconfig
config CYSEC
	tristate "CYSEC PCI driver support"
	depends on PCI
	select VIRTIO
	default n
```
